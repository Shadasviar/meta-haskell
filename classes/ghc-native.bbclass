DEPENDS += "ghc-native"

HC = "${RECIPE_SYSROOT_NATIVE}/${bindir_native}/ghc"
