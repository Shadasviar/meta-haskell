SUMMARY     = "Fast, pure and practical SHA-1 implementation"
DESCRIPTION = "A practical incremental and one-pass, pure API to the SHA-1 \
hash algorithm (including HMAC support) with performance close to the fastest \
implementations available in other languages. The implementation is made in \
C with a haskell FFI wrapper that hides the C implementation."

require cryptohash.inc

SRCREV = "f756ec31212f54fcaf1111fafd09edc604d27772"
