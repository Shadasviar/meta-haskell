SUMMARY     = "Efficient Streams"
DESCRIPTION = "Simple yet powerful monadic streams that are used as a \
backbone for vector package fusion functionality."

require vector.inc

DEPENDS += "ghc-prim"
