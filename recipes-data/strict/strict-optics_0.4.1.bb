SUMMARY     = "Optics for types in strict package"
DESCRIPTION = "Optics for types in strict package"

require strict.inc

DEPENDS += "optics-core strict"
