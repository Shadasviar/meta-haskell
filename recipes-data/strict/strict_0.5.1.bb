SUMMARY     = "Strict data types and String IO"
DESCRIPTION = "This package provides strict versions of some standard Haskell \
data types (pairs, Maybe and Either). It also contains strict IO operations."

require strict.inc

DEPENDS += "text these transformers"
