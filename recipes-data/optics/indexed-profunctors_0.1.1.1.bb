SUMMARY     = "Utilities for indexed profunctors"
DESCRIPTION = "This package contains basic definitions related to indexed \
profunctors. These are primarily intended as internal utilities to support \
the optics and generic-lens package families."

require optics.inc
