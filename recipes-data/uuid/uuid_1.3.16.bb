SUMMARY     = "For creating, comparing, parsing and printing Universally Unique Identifiers"
DESCRIPTION = "This library is useful for creating, comparing, parsing and \
printing Universally Unique Identifiers."

require uuid.inc

DEPENDS += "cryptohash-md5 cryptohash-sha1 entropy network-info random time uuid-types"
