SUMMARY     = "Extra utilities and instances for optics-core"
DESCRIPTION = "This package provides extra definitions and instances that \
extend the optics-core package, without incurring too many dependencies. \
See the optics package for more documentation."

require optics.inc

DEPENDS += "optics-core mtl text vector indexed-traversable-instances"
